<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\Hw1_1\Hw1_1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Hw1_2.ewp</path>
  </project>
  <batchBuild/>
</workspace>


