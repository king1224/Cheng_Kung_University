<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Lab8_sample.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\&#x8056;&#x8A95;&#x5C08;&#x984C;\Servo_Motor\Server_Motor_V1.ewp</path>
  </project>
  <batchBuild/>
</workspace>


