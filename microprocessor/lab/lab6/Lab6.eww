<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\Lab5\Lab5.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Lab6.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Lab6_C\Lab6_C.ewp</path>
  </project>
  <batchBuild/>
</workspace>


